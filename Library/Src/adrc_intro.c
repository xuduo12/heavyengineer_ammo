/*=============================================================================
 * 文件名称：adrc_intro.c
 * 适用对象：自抗扰控制器（ADRC）——学习/教学版算法实现，对应 adrc_intro.h
 *
 * 【一句话总结】
 *   自抗扰控制 = ①把对象"看不懂的那部分"(负载/摩擦/模型误差)统统算作"总扰动"；
 *                ②用 ESO 这个"眼睛"实时把它估出来；③在输出里把它直接抵消，
 *                让对象看起来像"干净的积分器"；④最后用普通 PD 就能控得很好。
 *
 * 【四个部件打个比方】想象你在开车去目标：
 *   TD   = 导航员  ：把"一步到位"的目标改成平滑路线，起步不猛冲；
 *   ESO  = 探路雷达：既估位置/速度，又顺带把"上坡、逆风、载重"这些
 *                    看不见的麻烦(总扰动)一起估出来；
 *   LSEF = 司机规则：看"还差多远、靠近多快"来踩油门(PD 控制)；
 *   扰动补偿       = 提前加油门：知道有上坡就多踩一点，把坡抵消掉。
 *
 * 【算法来源】
 *   韩京清《自抗扰控制技术》(2013) + 高志强 线性ADRC/带宽法 (Gao's LADRC)。
 *   本文件是"线性 ADRC"：ESO 与 LSEF 都用线性形式，且把所有参数收敛成
 *   两个带宽 w0 / wc，调参非常直观。
 *
 * 【被控对象模型与四大部件】
 *   以二阶位置环为例，被控对象写为：
 *             y'' = b0·u + f(t)
 *     其中 f(t) 是"总扰动"：外部负载、摩擦力、未建模动态、参数误差……
 *     全部被塞进这一个变量里，然后用 ESO 把它估计出来再抵消。
 *
 *   控制结构（每个控制周期依次执行）：
 *      ┌──────┐   v1,v2   ┌──────────────────────┐
 *  set→│  TD  │───v1,v2──→│  LSEF(PD): e1=v1-z1  │
 *      └──────┘           │            e2=v2-z2  │── u0 ──┐
 *                         └──────────┬───────────┘        │
 *                                    │ z1,z2,z3           │  u = (u0 - z3)/b0
 *                         ┌──────────┴───────────┐        │  (扰动补偿)
 *                     y,u→│ ESO（扩张状态观测器）│────────┘
 *                         └──────────────────────┘
 *
 *   1) TD   跟踪微分器   : 给 set 安排"过渡过程"，输出平滑的 v1（给定位置）
 *                         与 v2（给定速度），避免给定突变导致输出猛冲。
 *   2) ESO  扩张状态观测器: 唯一"扩张"出来的一维就是 z3（总扰动）。
 *   3) LSEF 线性误差反馈   : 对 (v−z) 做 PD 控制得虚拟控制量 u0。
 *   4) 扰动补偿          : u = (u0 − z3)/b0，把扰动抵消，控制对象退化成积分串联。
 *
 * 【单位与量纲】
 *   - 被控量单位任选（度、rpm、mm、rad…），只要 y 与 set 同单位即可。
 *   - u 单位 = 执行机构指令单位（如电流指令 ±16384），由 out_max 限制。
 *   - w0/wc 单位是 rad/s，与 h（秒）配合使用。
 *
 * 【与工程版 ADRC.c 的关系】
 *   算法与接口完全等价，仅两处"修正"：
 *     (1) 扰动补偿用标准形式 u = (u0 − zd)/b0（工程版写作 u0 − zd/b0，
 *         后者会破坏 wc 与闭环带宽的对应关系，且对 b0 偏大的鲁棒性差）；
 *     (2) 角度环绕处理中 max/2 用浮点运算、状态对齐统一以反馈量为基准，
 *         避免整数截断与观测残差导致的边界跳变。
 *   其余逐行逻辑与原版一致。
 *=====================================================================*/

#include "adrc_intro.h"
#include <math.h>   /* fabsf / sqrtf */

/*-----------------------------------------------------------------------------
 * 内部函数声明（不对外暴露）
 *----------------------------------------------------------------------------*/
static void ADRC_td_update(ADRC_type_def *ADRC, float target);  /* TD 步进 */
static void ADRC_eso_update(ADRC_type_def *ADRC, float y, float u); /* ESO 步进 */
static float ADRC_lsef_calc(ADRC_type_def *ADRC);               /* LSEF + 扰动补偿 */
static float ADRC_fhan(float v1, float v2, float r, float h);       /* 最速控制综合函数 */

/*-----------------------------------------------------------------------------
 * ADRC_Init —— 初始化
 *
 * 【通俗理解】给控制器"注册"一次：告诉它对象几阶、期望多快(wc)、观测多准(w0)、
 *   对象多大劲(b0)、周期多长(h)、输出能到多大(out_max)，内部系数它自己算好。
 *
 * 输入：
 *   order   : ADRC_VEL(速度环) 或 ADRC_POS(位置环)
 *   w0      : ESO 观测器带宽(rad/s)。ESO 收敛快慢 ≈ w0，
 *             一般取 wc 的 3~10 倍起步（见调参）。
 *   wc      : 控制器带宽(rad/s)。决定闭环响应快慢（≈ 闭环带宽）。
 *   b0      : 被控对象增益估计。量纲 = (被控量加速度) / 控制量u。
 *             例：位置环 "度/(电流指令·s²)"，速度环 "rpm/(电流指令·s)"。
 *   r       : TD 跟踪速度因子，越大过渡过程越快（但过大会牺牲平滑）。
 *   h       : 控制周期(秒)。注意：调用周期必须严格等于 h。
 *   out_max : 输出限幅，|u| ≤ out_max。
 *
 * 内部自动按带宽法整定：
 *   位置环(二阶)：β1=3w0, β2=3w0², β3=w0³ ; kp=wc², kd=2wc
 *   速度环(一阶)：β1=2w0, β2=w0²          ; kp=wc
 *  —— 所以初始化只需给两个带宽 w0、wc，不必手算 β 和 k。
 *----------------------------------------------------------------------------*/
void ADRC_Init(ADRC_type_def *ADRC, ADRC_order_e order, float w0, float wc, float b0, float r, float h, float out_max)
{
    /* 阶数与 TD 参数 */
    ADRC->order = order;    /* 记录阶数：决定 ESO 与 LSEF 用一阶还是二阶形式 */
    ADRC->td_r  = r;        /* TD 跟踪速度因子：越大，过渡过程越快但越"猛" */
    ADRC->td_h  = h;        /* 积分步长 = 控制周期(秒)，全文件所有 h 都用它 */
    ADRC->td_v1 = 0.0f;     /* v1（平滑位置给定）初始为 0 */
    ADRC->td_v2 = 0.0f;     /* v2（给定速度）    初始为 0 */

    /* ESO 参数：带宽法，由 w0 推出 β */
    ADRC->eso_w0 = w0;      /* 记录观测器带宽，供在线调参接口读取/更新 */
    /* b0 不能太小（避免除极小值），小于下限就钳到下限；正负号保留 */
    ADRC->eso_b0 = (fabsf(b0) >= ADRC_B0_MIN) ? b0 : ADRC_B0_MIN;
    if (order == ADRC_VEL)
    {
        /* 一阶 ESO（速度环）：观测 z1≈速度, z2≈总扰动。
         * 带宽法：极点配置在 -w0，特征多项式 (s+w0)² ⇒ β1=2w0, β2=w0² */
        ADRC->eso_beta1 = 2.0f * w0;
        ADRC->eso_beta2 = w0 * w0;
        ADRC->eso_beta3 = 0.0f;   /* 一阶没有 z3 */
    }
    else
    {
        /* 二阶 ESO（位置环）：观测 z1≈位置, z2≈速度, z3≈总扰动。
         * 带宽法：特征多项式 (s+w0)³ ⇒ β1=3w0, β2=3w0², β3=w0³ */
        ADRC->eso_beta1 = 3.0f * w0;
        ADRC->eso_beta2 = 3.0f * w0 * w0;
        ADRC->eso_beta3 = w0 * w0 * w0;
    }
    ADRC->eso_z1 = 0.0f;    /* z1（位置观测）初始为 0 */
    ADRC->eso_z2 = 0.0f;    /* z2（速度观测）初始为 0 */
    ADRC->eso_z3 = 0.0f;    /* z3（扰动观测）初始为 0 */

    /* LSEF 参数：由 wc 推出 kp/kd */
    ADRC->lsef_wc = wc;     /* 记录控制器带宽，供在线调参接口读取/更新 */
    if (order == ADRC_VEL)
    {
        /* 一阶对象只需比例：kp=wc（闭环极点 -wc） */
        ADRC->lsef_kp = wc;
        ADRC->lsef_kd = 0.0f;   /* 一阶对象没有"速度误差"可用，D 项置 0 */
    }
    else
    {
        /* 二阶对象用 PD：特征多项式 (s+wc)² ⇒ kp=wc², kd=2wc */
        ADRC->lsef_kp = wc * wc;
        ADRC->lsef_kd = 2.0f * wc;
    }

    /* 输出限幅与记录量 */
    ADRC->out_max = out_max;    /* 输出限幅，|u| 不会超过它 */
    ADRC->set   = 0.0f;         /* 记录：本周期目标给定 */
    ADRC->fdb   = 0.0f;         /* 记录：本周期反馈量 */
    ADRC->out   = 0.0f;         /* 记录：本周期输出（同时作为下周期 ESO 的输入） */
    ADRC->error = 0.0f;         /* 记录：误差（已环绕） */
    ADRC->disturbance = 0.0f;   /* 记录：总扰动观测值，方便调参观察 */
}

/*-----------------------------------------------------------------------------
 * ADRC_fhan —— 最速控制综合函数（TD 的核心）
 *
 * 【通俗理解】"老司机导航算法"：给定当前位置 v1、速度 v2，求一个"最聪明"的
 *   加速度指令 fh，让 v1 最短时间、最平滑地到达目标、还不超调。
 *   套路是：离目标还远 → 全油门猛冲(饱和区)；快到目标 → 提前线性减速(线性区)，
 *   保证到点刚好停稳。
 *
 * 输入：v1, v2（TD 当前状态），r（速度因子），h（步长）
 * 输出：使 v1 最快收敛到目标、且不超调的最速控制量 fh
 *
 * 数学形式（韩京清，符号与下方代码一致，切换点命名为 a1）：
 *   d  = r·h;  d0 = h·d;  y = v1 + h·v2;
 *   a1 = sqrt(d² + 8·r·|y|);
 *   a  = |y|≤d0 ? v2 + y/h : v2 + sign(y)·(a1−d)/2;
 *   fh = |a|≤d  ? −r·a/d  : −r·sign(a);
 * 它本质上是一个"离散化后的 bang-bang 型最速跟踪"，保证：
 *   - 过渡过程最短时间收敛（远离目标满幅、接近目标提前线性减速）；
 *   - 给定的位置、速度曲线全程平滑（导数有界）；
 *   - 输出不会超调。
 * 注：教材另给出带滤波步长 h0 的"滤波版 fhan(v1,v2,r,h0)"，
 *     当 h0 取 h 时滤波版与上式完全相同，本代码即此常用版本。
 *----------------------------------------------------------------------------*/
static float ADRC_fhan(float v1, float v2, float r, float h)
{
    /* d = r·h：速度因子的离散化"力度"，决定了切换带宽度 */
    float d  = r * h;
    /* d0 = h·d = r·h²：位置误差 y 的线性区边界（一步内能消掉的误差） */
    float d0 = h * d;
    /* y = v1 + h·v2：预测"一步之后"的位置误差（考虑当前速度的推进） */
    float y  = v1 + h * v2;
    float a;         /* a：等效加速度（先按当前速度外推，再作最速修正） */
    /* a1 = sqrt(d² + 8·r·|y|)：由 bang-bang 最优控制解出的"加速度切换点"。
     * 它对应最优轨迹在相平面上的切换抛物线边界，取值只在 a 落在饱和区时用到。 */
    float a1;
    a1 = sqrtf(d * d + 8.0f * r * fabsf(y));
    if (fabsf(y) <= d0)          /* 线性区：误差在切换带内，用线性加速度 */
    {
        /* 位置误差足够小、一步内可消除：直接按"速度 + 一步消完误差"给加速度 */
        a = v2 + y / h;
    }
    else                         /* 饱和区：误差在切换带外，用最速(bang-bang) */
    {
        /* 误差大：沿切换边界走最优轨迹，加速度落在饱和点附近（符号随 y） */
        if (y > 0.0f)
            a = v2 + (a1 - d) / 2.0f;
        else
            a = v2 - (a1 - d) / 2.0f;
    }
    /* 最后对 a 做"饱和限幅"：|a|≤d 内线性返回 −r·a/d，否则直接输出 ±r。
     * 形式上等价于 fh = −r·sat(a, d)，d 就是饱和（切换）边界宽度。 */
    if (fabsf(a) <= d)
    {
        return -r * a / d;   /* 线性区：力度随误差成正比，柔和平稳 */
    }
    else
    {
        return (a > 0.0f) ? -r : r;   /* 饱和区：输出最大加速度 ±r，全力跟踪 */
    }
}

/*-----------------------------------------------------------------------------
 * ADRC_td_update —— TD 步进（离散化 Euler 积分）
 *
 * 【通俗理解】给目标"做平滑"：直接把目标塞给电机，起步会猛冲。TD 把它变成
 *   "会拐弯的斜坡"：位置 v1 每次加 速度×步长；该加速还是该刹车由 fhan 说了算。
 *   结果 v1 平滑逼近目标、不超调，v2 就是配套的平滑速度。
 *
 * 作用：把目标给定 target 平滑成 v1、v2 两个状态：
 *       v1 += h·v2;                    （位置 = 位置 + h×速度）
 *       v2 += h·fhan(v1−target, v2, r, h);   （速度按最速控制调整）
 * 效果：v1 平滑逼近 target（不超调），v2 就是 v1 的导数（带滤波的速度给定）。
 * 这样把"阶跃给定"变成"梯形/三角速度曲线"，从根源上避免超调。
 *----------------------------------------------------------------------------*/
static void ADRC_td_update(ADRC_type_def *ADRC, float target)
{
    float v1 = ADRC->td_v1;     /* 读出当前 v1（平滑位置给定） */
    float v2 = ADRC->td_v2;     /* 读出当前 v2（给定速度） */
    float r  = ADRC->td_r;      /* 跟踪速度因子 */
    float h  = ADRC->td_h;      /* 积分步长 */
    /* fhan 的输入是 (v1 − target)：把"离目标还有多远"喂给最速控制。
     * 注意 target 是"目标值"，误差方向是 v1 靠近 target，故用 v1 − target */
    float fh = ADRC_fhan(v1 - target, v2, r, h);
    /* Euler 积分：位置 + 速度×步长 */
    ADRC->td_v1 = v1 + h * v2;
    /* Euler 积分：速度 + 最速控制加速度×步长 */
    ADRC->td_v2 = v2 + h * fh;
}

/*-----------------------------------------------------------------------------
 * ADRC_eso_update —— ESO（扩张状态观测器）步进
 *
 * 【通俗理解】ESO 是"内部模拟器 + 纠错器"：在脑子里模拟对象，把已知输入 b0·u
 *   塞进去推算出应有的输出 z1；再拿 z1 和实测 y 一比，差值 e 就是"没算对的部分"。
 *   用 e 乘上增益 β 反馈回去，一点点把 z1、z2、z3 修正到真实值。
 *   关键在"扩张"多出的 z3：它专门记"所有没被 b0·u 解释掉的麻烦"，即总扰动 f(t)。
 *   调好了：z1→y、z2→y'、z3→f(t)。
 *
 * 输入：y = 反馈量实测值，u = 控制器上一周期输出
 *
 * 二阶形式（位置环，离散 Euler）：
 *   e = z1 − y;                          // 观测误差
 *   z1 += h·(z2 − β1·e);                 // 位置观测
 *   z2 += h·(z3 − β2·e + b0·u);          // 速度观测（含已知输入 b0·u 驱动）
 *   z3 += h·(−β3·e);                     // 总扰动观测（这就是"扩张"出来的状态）
 *
 * 一阶形式（速度环）：
 *   e = z1 − y;
 *   z1 += h·(z2 − β1·e + b0·u);
 *   z2 += h·(−β2·e);                     // 此时 z2 直接就是总扰动
 *
 * 直观理解：ESO 就像一个"反向积分器 + 反馈校正"的模型：它把已知的
 * 输入 b0·u 送进去，再用 (y − z1) 这个残差去修正 z1、z2、z3。
 * 当修正到位时：z1→y，z2→y'，z3→f(t)，残差 e→0。
 * 收敛速度由 β 决定，而 β 由 w0 决定（β∝w0ⁿ），这就是带宽法。
 *----------------------------------------------------------------------------*/
static void ADRC_eso_update(ADRC_type_def *ADRC, float y, float u)
{
    float h  = ADRC->td_h;    /* 步长 = 控制周期 */
    float b0 = ADRC->eso_b0;  /* 对象增益估计：ESO 内部要模拟 b0·u 这一"已知驱动" */
    float b1 = ADRC->eso_beta1; /* 观测器增益 β1 */
    float b2 = ADRC->eso_beta2; /* 观测器增益 β2 */
    float b3 = ADRC->eso_beta3; /* 观测器增益 β3（位置环用） */
    /* 观测误差：用"上一时刻 z1"与当前反馈 y 的差（Euler 显式） */
    float e = ADRC->eso_z1 - y;
    if (ADRC->order == ADRC_VEL)
    {
        /* 一阶：z1≈速度，z2≈扰动。
         * 状态方程：y' = b0·u + f，故 z1 的驱动项含 b0·u，z2 只由误差修正。 */
        ADRC->eso_z1 = ADRC->eso_z1 + h * (ADRC->eso_z2 - b1 * e + b0 * u);
        ADRC->eso_z2 = ADRC->eso_z2 + h * (-b2 * e);
        ADRC->eso_z3 = 0.0f;   /* 一阶没有 z3，保持 0 */
    }
    else
    {
        /* 二阶：z1≈位置，z2≈速度，z3≈扰动。
         * 状态方程：y'' = b0·u + f，故 z2 的驱动项含 b0·u，z3 只由误差修正。 */
        ADRC->eso_z1 = ADRC->eso_z1 + h * (ADRC->eso_z2 - b1 * e);
        ADRC->eso_z2 = ADRC->eso_z2 + h * (ADRC->eso_z3 - b2 * e + b0 * u);
        ADRC->eso_z3 = ADRC->eso_z3 + h * (-b3 * e);
    }
}

/*-----------------------------------------------------------------------------
 * ADRC_lsef_calc —— 线性误差反馈(LSEF) + 扰动补偿
 *
 * 【通俗理解】最后两步：
 *   ① 先当普通 PD 控制算：把"给定 − 观测"的误差(e1,e2)放大成 u0，
 *      像司机看"还差多远、靠近多快"来决定踩多少油门；
 *   ② 再把 ESO 测到的总扰动 zd 补偿掉：u = (u0 − zd)/b0。
 *      知道有上坡就多踩一点，把坡抵消 → 对象变成 y''≈u0 的干净积分器，
 *      普通 PD 就足够好。这就是 ADRC 抗扰的本质。
 *
 * 1) 误差：e1 = v1 − z1（给定位置 − 观测位置）
 *           e2 = v2 − z2（给定速度 − 观测速度）
 *    注意：用的是 TD 的平滑给定 v1,v2，而不是原始 set，所以给定量是连续平滑的。
 * 2) 虚拟控制量（PD）：u0 = kp·e1 + kd·e2
 * 3) 扰动补偿：u = (u0 − zd)/b0
 *    当 z3≈f(t) 时，作用于对象后：
 *        y'' = b0·u + f = u0 − z3 + f ≈ u0
 *    扰动被完全抵消，系统退化为 y''=u0 的"纯积分串联"对象，
 *    PD 就能获得良好动态。这就是 ADRC 的抗扰本质。
 *    （若写作 u0 − zd/b0，则闭环灵敏度随 b0 偏移，w0/wc 与带宽的对应关系被破坏）
 *----------------------------------------------------------------------------*/
static float ADRC_lsef_calc(ADRC_type_def *ADRC)
{
    /* e1：位置误差（TD 平滑给定 − ESO 位置观测） */
    float e1 = ADRC->td_v1 - ADRC->eso_z1;
    float u0;    /* 虚拟控制量（先做 PD，再除 b0 还原到执行器量纲） */
    float zd;    /* 总扰动的观测值（位置环取 z3，速度环取 z2） */
    if (ADRC->order == ADRC_VEL)
    {
        /* 速度环：纯比例（一阶对象，PD 的 D 项不需要） */
        u0 = ADRC->lsef_kp * e1;
        zd = ADRC->eso_z2;   /* 一阶 ESO 里 z2 就是扰动 */
    }
    else
    {
        /* 位置环：PD 控制 */
        float e2 = ADRC->td_v2 - ADRC->eso_z2;   /* 速度误差 */
        u0 = ADRC->lsef_kp * e1 + ADRC->lsef_kd * e2;
        zd = ADRC->eso_z3;   /* 二阶 ESO 里 z3 就是扰动 */
    }
    float b0 = ADRC->eso_b0;
    /* 兜底：绝不允许除以极小值（保护性钳位，保留符号） */
    if (fabsf(b0) < ADRC_B0_MIN)
        b0 = (b0 >= 0.0f) ? ADRC_B0_MIN : -ADRC_B0_MIN;
    /* 扰动补偿：u = (u0 − zd)/b0。
     * 除 b0 把"虚拟控制量"还原为"执行器指令量纲"，
     * 减 zd 把观测到的总扰动直接抵消。 */
    float u = (u0 - zd) / b0;
    return u;
}

/*-----------------------------------------------------------------------------
 * ADRC_Calc —— ADRC 主计算入口（每个固定周期调用一次）
 *
 * 【通俗理解】一个控制周期按顺序做 6 件事：
 *   ① 算误差(角度则绕最短路径)；② 把 z1、v1 与当前角度对齐到同一圈防跳变；
 *   ③ 把目标也搬进同一圈；④ TD 给目标做平滑 → v1,v2；
 *   ⑤ ESO 用"反馈+上周期输出"更新观测 → z1,z2,z3；⑥ LSEF+补偿得 u 并限幅。
 *
 * 输入：
 *   ref : 反馈量（实测位置/速度）
 *   set : 目标量（目标位置/目标速度）
 *   max : 角度量程。0=线性量不做环绕；非 0（如 8192、360）做循环环绕，
 *         保证误差走最短路径。
 * 输出：u（已限幅，可直接下发执行机构）
 *
 * 流程：
 *   1) 记录 set/ref，计算误差 error（带环绕）；
 *   2) 若 max≠0，把 ESO 的 z1、TD 的 v1 也做环绕对齐，避免它们因
 *      数值突变在边界产生跳变；
 *   3) 对"目标给定"做环绕，得到用于 TD 的 target；
 *   4) TD 步进：target → v1, v2；
 *   5) ESO 步进：用 (ref, 上一周期输出 out) 更新 z1,z2,z3；
 *   6) LSEF + 扰动补偿得到 u，限幅后输出。
 *----------------------------------------------------------------------------*/
float ADRC_Calc(ADRC_type_def *ADRC, float ref, float set, int max)
{
    /* ① 记录与误差（带环绕） */
    ADRC->fdb = ref;     /* 记录反馈量 */
    ADRC->set = set;     /* 记录给定 */
    float error = set - ref;   /* 原始误差：目标 − 反馈 */
    if (max != 0)   /* 角度环绕：把误差搬到 [-max/2, +max/2) */
    {
        /* 若误差超过半圈，就减/加一整圈，保证走最短路径。
         * 这里用浮点 (float)max 再除以 2，避免整数除法截断 */
        if (error >= (float)max / 2.0f)
            error -= (float)max;
        if (error < -(float)max / 2.0f)
            error += (float)max;
    }
    ADRC->error = error;   /* 记录环绕后的误差 */

    /* ② 状态环绕对齐：让 z1、v1 与 ref 处在同一周期内。
     *    以"当前反馈 ref"为基准（而不是以上一次 z1 为基准），
     *    避免基准自身漂移导致状态在两周期间来回跳。 */
    if (max != 0)
    {
        float half_max = (float)max / 2.0f;  /* 半圈长度（浮点） */
        float fmax     = (float)max;         /* 一整圈长度 */
        /* z1 与反馈的差若超过半圈，就把 z1 平移一整圈 */
        float e_z1 = ADRC->eso_z1 - ref;
        if (e_z1 >= half_max)
            ADRC->eso_z1 -= fmax;
        else if (e_z1 < -half_max)
            ADRC->eso_z1 += fmax;
        /* v1 与 z1 的差若超过半圈，就把 v1 平移一整圈（v1 应贴近 z1） */
        float e_v1 = ADRC->td_v1 - ADRC->eso_z1;
        if (e_v1 >= half_max)
            ADRC->td_v1 -= fmax;
        else if (e_v1 < -half_max)
            ADRC->td_v1 += fmax;
    }

    /* ③ 目标环绕：TD 的输入 target 也搬进同一周期 */
    float target = set;
    if (max != 0)
    {
        float half_max = (float)max / 2.0f;
        float fmax     = (float)max;
        /* 让"目标"与"当前 z1 观测"的差落在半圈内，保证最短路径 */
        float diff = target - ADRC->eso_z1;
        if (diff >= half_max)
            target -= fmax;
        else if (diff < -half_max)
            target += fmax;
    }

    /* ④ TD 步进（安排过渡过程）：target → v1, v2 */
    ADRC_td_update(ADRC, target);
    /* ⑤ ESO 步进（观测状态与扰动），u 用上一周期的 out */
    ADRC_eso_update(ADRC, ref, ADRC->out);
    /* ⑥ LSEF + 扰动补偿：u = (u0 − zd)/b0 */
    float u = ADRC_lsef_calc(ADRC);

    /* 输出限幅：|u| 不超过 out_max */
    if (u > ADRC->out_max)
        u = ADRC->out_max;
    if (u < -ADRC->out_max)
        u = -ADRC->out_max;
    ADRC->out = u;   /* 保存本周期输出，作为下周期 ESO 的驱动输入 */
    /* 记录扰动观测值（速度环 z2 / 位置环 z3），方便调参观察 */
    ADRC->disturbance = (ADRC->order == ADRC_VEL) ? ADRC->eso_z2 : ADRC->eso_z3;
    return u;
}

/*-----------------------------------------------------------------------------
 * 在线调参接口
 * 【通俗理解】整个 ADRC 只需要两个"旋钮"：w0(观测多快)、wc(控制多快)。
 *   内部所有系数(β、kp、kd)都由它们推导，所以运行中直接拧旋钮，下周期生效。
 * 原理：ADRC 的 β 与 k 都可由带宽唯一确定（带宽法），所以运行时
 *       只需更新带宽，系数自动重算，下一周期即生效，无需重新初始化。
 *----------------------------------------------------------------------------*/

/* 在线改 ESO 观测器带宽 w0 */
void ADRC_SetESOBandwidth(ADRC_type_def *ADRC, float w0)
{
    if (w0 <= 0.0f) return;   /* 非法输入直接忽略 */
    ADRC->eso_w0 = w0;
    if (ADRC->order == ADRC_VEL)
    {
        ADRC->eso_beta1 = 2.0f * w0;
        ADRC->eso_beta2 = w0 * w0;
    }
    else
    {
        ADRC->eso_beta1 = 3.0f * w0;
        ADRC->eso_beta2 = 3.0f * w0 * w0;
        ADRC->eso_beta3 = w0 * w0 * w0;
    }
}

/* 在线改控制器带宽 wc */
void ADRC_SetControllerBandwidth(ADRC_type_def *ADRC, float wc)
{
    if (wc <= 0.0f) return;
    ADRC->lsef_wc = wc;
    if (ADRC->order == ADRC_VEL)
    {
        ADRC->lsef_kp = wc;
    }
    else
    {
        ADRC->lsef_kp = wc * wc;
        ADRC->lsef_kd = 2.0f * wc;
    }
}

/* 在线更新 b0（例如负载明显变化后重新辨识） */
void ADRC_SetB0(ADRC_type_def *ADRC, float b0)
{
    ADRC->eso_b0 = (fabsf(b0) >= ADRC_B0_MIN) ? b0 : ADRC_B0_MIN;
}

/* 在线改输出限幅 */
void ADRC_SetOutMax(ADRC_type_def *ADRC, float out_max)
{
    ADRC->out_max = out_max;
}

/* 在线改控制周期 */
void ADRC_SetControlPeriod(ADRC_type_def *ADRC, float h)
{
    ADRC->td_h = h;
}

/*-----------------------------------------------------------------------------
 * ADRC_Reset —— 复位
 * 【通俗理解】"熄火重启"：状态全清零、参数(w0/wc/b0/r/h/out_max)保留。
 * 清空 TD / ESO 全部状态（v1,v2,z1,z2,z3）与输出。
 * 适用场景：电机重新上电、切换到新对象、需要重新起机时调用。
 * 注意：不清空参数（w0/wc/b0/r/h/out_max 保留），只清状态。
 *----------------------------------------------------------------------------*/
void ADRC_Reset(ADRC_type_def *ADRC)
{
    ADRC->td_v1 = 0.0f;
    ADRC->td_v2 = 0.0f;
    ADRC->eso_z1 = 0.0f;
    ADRC->eso_z2 = 0.0f;
    ADRC->eso_z3 = 0.0f;
    ADRC->out = 0.0f;
    ADRC->error = 0.0f;
    ADRC->disturbance = 0.0f;
}

/*=============================================================================
 * 附：参数设置步骤速查（详见调用方文档/README）
 *
 *  ① 定 h    ：控制周期（必须与中断周期一致，单位秒）。
 *  ② 定 r    ：TD 跟踪速度因子，先给大一点（≈ 0.1~0.5×out_max/h）。
 *  ③ 定 b0   ：估算被控对象增益：给一个已知 u，测稳态加速度/速度变化率，
 *               b0 ≈ 变化量 / u。量级对即可（偏小30%比偏大60%安全）。
 *  ④ 调 wc   ：从 10~15 起步，逐步加大到响应符合要求或出现轻微振荡，
 *               然后退回 ~20%。wc 决定闭环响应快慢。
 *  ⑤ 调 w0   ：从 3~10×wc 起步，抗扰不足就加大；过大则噪声放大、输出抖。
 *               最终 w0 常取 5~10×wc。
 *  ⑥ 验证    ：带载突变，看 adrc_1.disturbance 是否快速跟上、输出平滑补偿；
 *               观察 z1 是否紧跟 y、v1 是否平滑跟给定。
 *=====================================================================*/
